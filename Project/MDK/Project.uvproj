# Keil uVision project Project.uvproj, settings and files
target VC3101 (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: Project
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F4XX,ARM_MATH_CM4,__CC_ARM
  c include: ..\..\App;..\..\Bsp;..\..\HardWareLib\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\HardWareLib\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\Components\GUI\emWin\Config;..\..\Components\GUI\emWin\GUI_X;..\..\Components\GUI\emWin\Include;..\..\Components\GUI\emWin\uCGUIDemo;..\..\Components\RTOS\uCOS-III\uC-CPU;..\..\Components\RTOS\uCOS-III\uC-CPU\ARM-Cortex-M4\RealView;..\..\Components\RTOS\uCOS-III\uC-LIB;..\..\Components\RTOS\uCOS-III\uC-LIB\Ports\ARM-Cortex-M4\RealView;..\..\Components\RTOS\uCOS-III\uCOS-III\Ports;..\..\Components\RTOS\uCOS-III\uCOS-III\Ports\ARM-Cortex-M4\Generic\RealView;..\..\Components\RTOS\uCOS-III\uCOS-III\Source;..\..\Components\RTOS\uC-Serial\Driver\ST;..\..\Components\RTOS\uC-Serial\Driver\ST\STM3240x;..\..\Components\RTOS\uC-Serial\Line;..\..\Components\RTOS\uC-Serial\OS;..\..\Components\RTOS\uC-Serial\Source
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group App
    ../../App/: main.c stm32f4xx_it.c FramewinDLG.c
  group Bsp
    ../../Bsp/: bsp.c bsp_lcd.c bsp_led.c
  group RVMDK
    ../../HardWareLib/Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f4xx.s
  group StdPeriph_Driver
    ../../HardWareLib/Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group CMSIS
    ../../HardWareLib/Libraries/: system_stm32f4xx.c
  group GUI_Driver
    ../../Components/GUI/emWin/DisplayDriver/: GUIDRV_Template.c
  group GUI_X
    ../../Components/GUI/emWin/GUI_X/: GUI_X.c GUI_X_Touch.c
  group GUI_Config
    ../../Components/GUI/emWin/Config/: GUIConf.c LCDConf.c GUIConf.h LCDConf.h
  group GUI_Lib
    ../../Components/GUI/emWin/GUILib/: GUI_CM3.lib
  group uC/CPU
    ../../Components/RTOS/uCOS-III/uC-CPU/: cpu_core.c cpu_core.h cpu_def.h
    ../../Components/RTOS/uCOS-III/uC-CPU/ARM-Cortex-M4/RealView/: cpu.h cpu_a.asm cpu_c.c
  group uC/LIB
    ../../Components/RTOS/uCOS-III/uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.h lib_str.c lib_str.h lib_mem.c
    ../../Components/RTOS/uCOS-III/uC-LIB/Ports/ARM-Cortex-M4/RealView/: lib_mem_a.asm
  group uC/OS-III Source
    ../../Components/RTOS/uCOS-III/uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group uC/OS-III Port
    ../../Components/RTOS/uCOS-III/uCOS-III/Ports/ARM-Cortex-M4/Generic/RealView/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group uC/OS-III Cfg
    ../../App/: cpu_cfg.h lib_cfg.h os_cfg.h os_cfg_app.h
